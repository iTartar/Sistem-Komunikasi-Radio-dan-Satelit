options:
  parameters:
    author: Aqil
    generate_options: qt_gui
    id: Praktikum1e
    output_language: python
    title: Praktikum 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    size: '256'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle2_0_1, '0']
- [blocks_throttle2_0_1, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_throttle2_0_1, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0_1, '0', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
