options:
  parameters:
    generate_options: hb
    id: AddingBlock
    output_language: python
    title: AddingBlock
  states: {}

blocks:
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '32000'
  states: {}

connections:
- [analog_sig_source_x_2_0, '0', blocks_throttle2_1_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_throttle2_1_0, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
